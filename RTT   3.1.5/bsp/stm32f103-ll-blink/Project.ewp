# IAR project Project.ewp, settings and files
configuration stm32f103-led (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xB; USE_FULL_LL_DRIVER; HSE_VALUE=8000000; HSE_STARTUP_TIMEOUT=100; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; HSI_VALUE=8000000; LSI_VALUE=40000; VDD_VALUE=3300; PREFETCH_ENABLE=1
  ICCARM.CCIncludePath2: ; libraries/STM32F1xx_HAL_Driver/Inc; libraries/CMSIS/Device/ST/STM32F1xx/Include; libraries/CMSIS/Include; ..\..\include; ..\..\include\libc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32f103-led.hex
  ILINK.IlinkOutputFile: stm32f103-led.out
  ILINK.IlinkIcfFile: libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/linker/stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Applications
    applications/: main.c
  group rtthread
    RTE/RTOS/: board.c
    ../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
    ../../libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group STM32-LIB
    libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xb.s
    libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_gpio.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_usart.c stm32f1xx_ll_utils.c
    libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
